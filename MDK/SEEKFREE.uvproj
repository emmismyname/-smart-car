# Keil uVision project SEEKFREE.uvproj, settings and files
target STC32F12K (MCS-251)
  device: STC32F12K64 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  link misc: REMOVEUNUSED
  group startup
    ../../Libraries/libraries/: board.c board.h common.c common.h STC32Gxx.h
  group seekfree_libraries
    ../../Libraries/seekfree_peripheral/: headfile.h
    ../../Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_eeprom.c zf_eeprom.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_nvic.c zf_nvic.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h zf_fifo.c zf_fifo.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: headfile.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_BLUETOOTH_CH9141.h SEEKFREE_CONFIG.LIB SEEKFREE_CONFIG.h SEEKFREE_DL1A.c SEEKFREE_DL1A.h SEEKFREE_DL1B.c SEEKFREE_DL1B.h SEEKFREE_FUNCTION.c SEEKFREE_FUNCTION.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group doc
    ../../Libraries/doc/: version.txt
  group user_c
    ../USER/src/: eeprom.c imu.c Soft_I2C.c MPU6050.c assistant.c DMP.c isr.c main.c motor.c data.c car_state.c carcontrol.c
  group user_h
    ../USER/inc/: car_state.h DMP.h MPU6050.h Soft_I2C.h stdint.h isr.h mycode.h motor.h data.h assistant.h carcontrol.h imu.h eeprom.h
  group seekfree_components
    ../../Libraries/seekfree_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_inface.c
