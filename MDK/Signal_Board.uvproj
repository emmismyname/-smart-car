# Keil uVision project Signal_Board.uvproj, settings and files
target STC32F12K (MCS-251)
  device: STC32F12K54 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Signal_Board +hex
  link misc: REMOVEUNUSED
  group startup
    ../LIB/startup/: board.c common.c board.h common.h STC32Gxx.h STDIO.H INTRINS.H FLOAT.H MATH.H STRING.H
  group libraries
    ../LIB/libraries/: adc.c adc.h delay.c delay.h eeprom.c eeprom.h exti.c exti.h fifo.c fifo.h gpio.c gpio.h iic.c iic.h mdu16.c mdu16.h nvic.c nvic.h pwm.c pwm.h spi.c spi.h tim.c tim.h uart.c uart.h
  group doc
    ./Document/: pins.txt version.txt
  group user_c
    ../USER/src/: isr.c main.c adc_acquire.c pid.c init.c data_read.c data_send.c element.c carcontrol.c
  group user_h
    ../USER/inc/: isr.h adc_acquire.h header.h pid.h init.h data_read.h data_send.h element.h
  group peripheral
    ../LIB/peripheral/: CONFIG.h CONFIG.LIB DL1A.c DL1A.h DL1B.c DL1B.h FUNCTION.c FUNCTION.h headfile.h TSL1401.c TSL1401.h WIRELESS.c WIRELESS.h
